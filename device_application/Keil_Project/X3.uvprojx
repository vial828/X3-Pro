# Keil uVision project X3.uvprojx, settings and files
target stratos_f (6120000::V6.12::.\ARMCLANG)
  device: GD32W515PIQ6 GigaDevice
  pack: GigaDevice.GD32W51x_DFP.1.0.1
  cpu: IRAM(0x20000000,0x70000) IRAM2(0x30000000,0x70000) IROM(0x08000000,0x0200000) IROM2(0x0C000000,0x0200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: Project +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 v6Lang=4 v6LangP=5 wLevel=3
  c define: USE_STDPERIPH_DRIVER,SYS_NS,GD32W515PI
  c include: ..\Firmware\CMSIS;..\Firmware\CMSIS\GD\GD32W51x\Include;..\Firmware\GD32W51x_standard_peripheral\Include;..\Utilities;..\hwi;..\App;..\Dev;..\Inc;..\Kernel;..\SecureComm;..\Test;..\;..\App\app_pd;..\FreeRTOS\Source\include;..\FreeRTOS\Source\portable\GCC\ARM_CM33_NTZ\non_secure
  library: MicroLIB
  memory RVCT4: ROM 0x8011000 size 0x1ef000
  memory RVCT5: ROM 0xc000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x70000
  memory RVCT10: RAM 0x30000000 size 0x70000
  group Application
    ../: main.c gd32w51x_it.c
    ../App/: cit.c comm.c error_code.c error_code_led_output.c log.c manager.c update_cmd.c usr_cmd.c wdg.c app_heat.c app_charge.c app_haptic.c app_button.c app_oled_display.c app_oled_UI.c
    ../App/app_pd/: app_pd_cfg.c app_pd_com.c app_pd_snk.c app_pd_typec.c
  group CMSIS
    ../Firmware/CMSIS/GD/GD32W51x/Source/: system_gd32w51x.c
  group Peripheral
    ../Firmware/GD32W51x_standard_peripheral/Source/: gd32w51x_adc.c gd32w51x_cau.c gd32w51x_cau_aes.c gd32w51x_cau_des.c gd32w51x_cau_tdes.c gd32w51x_crc.c gd32w51x_dbg.c gd32w51x_dci.c gd32w51x_dma.c gd32w51x_efuse.c gd32w51x_exti.c gd32w51x_fmc.c gd32w51x_fwdgt.c gd32w51x_gpio.c gd32w51x_hau.c gd32w51x_hau_sha_md5.c gd32w51x_hpdf.c gd32w51x_i2c.c gd32w51x_icache.c gd32w51x_misc.c gd32w51x_pkcau.c gd32w51x_pmu.c gd32w51x_qspi.c gd32w51x_rcu.c gd32w51x_rtc.c gd32w51x_sdio.c gd32w51x_spi.c gd32w51x_sqpi.c gd32w51x_syscfg.c gd32w51x_timer.c gd32w51x_trng.c gd32w51x_tsi.c gd32w51x_tzpcu.c gd32w51x_usart.c gd32w51x_wwdgt.c
  group Startup
    ../Firmware/CMSIS/GD/GD32W51x/Source/ARM/: startup_gd32w51x.s
  group Hwi
    ../hwi/: HWI_adc.c HWI_flash.c HWI_gpio.c HWI_Hal.c HWI_i2c.c HWI_power.c HWI_pwm.c HWI_rtc.c HWI_systick.c HWI_trng.c HWI_uart.c HWI_wdg.c
  group Dev
    ../Dev/: dev_adc.c dev_bq25898x.c dev_cap_aw9320x.c dev_cap_aw9320x_application.c dev_gauge_bq27z561r2.c dev_pd_sy69410vws.c dev_pwm_ll.c dev_temperature.c gd25qxx.c i2c.c mp2731.c power.c rtc.c self_flash.c uart.c dev_oled_driver.c
  group Kernel
    ../Kernel/: batTimer.c kernel.c message.c taskInit.c
  group Test
    ../Test/: performance.c uart_cmd.c
  group Inc
    ../Inc/: main.h stratos_defs.h FreeRTOSConfig.h version.h
  group SecureComm
    ../SecureComm/: base64.c sha256.c uECC.c
  group FreeRTOS
    ../FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../FreeRTOS/Source/portable/GCC/ARM_CM33_NTZ/non_secure/: port.c portasm.c
    ../FreeRTOS/: freertos_helper.c
    ../FreeRTOS/Source/portable/MemMang/: heap_4.c
target stratos_u (6120000::V6.12::.\ARMCLANG)
  device: GD32W515PIQ6 GigaDevice
  pack: GigaDevice.GD32W51x_DFP.1.0.1
  cpu: as above
  output: Project +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_STDPERIPH_DRIVER,SYS_NS,GD32W515PI,SSCOM
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8011000 size 0x1e0000
  memory RVCT5: ROM 0xc000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x70000
  memory RVCT10: RAM 0x30000000 size 0x70000
software components: CMSIS:CORE 5.2.0
